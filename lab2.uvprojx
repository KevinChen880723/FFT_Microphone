# Keil uVision project lab2.uvprojx, settings and files
target lab2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: lab2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_HAL_DRIVER,STM32F746xx
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;..\Drivers\BSP\STM32746G-Discovery;..\Drivers\BSP\Components\ft5336;..\Drivers\BSP\Components\Common;..\Drivers\BSP\Components\wm8994;..\Drivers\CMSIS\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: main.c bsp_driver_sd.c sd_diskio.c fatfs.c fatfs_platform.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
    C:/Users/WTC/STM32Cube/Repository/STM32Cube_FW_F7_V1.15.0/Drivers/CMSIS/Lib/ARM/: arm_cortexM7lfsp_math.lib
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group BSP
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c stm32746g_discovery_ts.h stm32746g_discovery.c stm32746g_discovery_audio.c
    ../Drivers/BSP/Components/ft5336/: ft5336.c ft5336.h
    ../Drivers/BSP/Components/wm8994/: wm8994.c
  group CMSIS
    ../Drivers/CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../Drivers/CMSIS/DSP/Source/TransformFunctions/: arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_cfft_f32.c arm_cfft_radix2_init_q15.c
    ../Drivers/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
software components: CMSIS:CORE 4.3.0
